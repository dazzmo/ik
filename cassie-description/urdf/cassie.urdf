Commit message: Updated cassie example to showcase capabilities, updated readme and improved frame task documentation

File: cassie-description/urdf/cassie.urdf (robot description, URDF)
Before this commit: robot cassie, 23 links, 22 joints
Joints:
- joint base_joint: type floating -> fixed
